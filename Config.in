## Config.in
```kconfig
config BR2_PACKAGE_GIMBAL_RPI
	bool "gimbal-rpi"
	help
	  TIGERs Tracking Gimbal Application.
```
